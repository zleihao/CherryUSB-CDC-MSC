# Keil uVision project stm32f4.uvprojx, settings and files
target stm32f4 (5050169::V5.05 update 2 (build 169)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\Library\CMSIS\Include;..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Applications;..\Applications\RtosCommon;..\FreeRTOS\inc;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CherryUSB-1.4.0\class\cdc;..\CherryUSB-1.4.0\class\hid;..\CherryUSB-1.4.0\common;..\CherryUSB-1.4.0\core;..\CherryUSB-1.4.0\port\dwc2;..\Applications\w25qxx;..\Applications\FATFS;..\CherryUSB-1.4.0\class\msc;..\CherryRB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ../Applications/: main.c stm32f4xx_it.c usb_task.c led_task.c usart.c
    ../Applications/RtosCommon/: free_rtos.c
    ../Applications/w25qxx/: bsp_spi_flash.c
  group Config
    ../Applications/: usb_config.h
    ../FreeRTOS/inc/: FreeRTOSConfig.h
  group CMSIS
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Startup
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Library
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Doc
    ../Doc/: Readme.txt
  group CherryUSB
    ../CherryUSB-1.4.0/class/cdc/: usbd_cdc_acm.c
    ../CherryUSB-1.4.0/class/hid/: usbd_hid.c
    ../CherryUSB-1.4.0/core/: usbd_core.c
    ../CherryUSB-1.4.0/port/dwc2/: usb_dc_dwc2.c
    ../CherryUSB-1.4.0/class/msc/: usbd_msc.c
  group CherryRB
    ../CherryRB/: chry_ringbuffer.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FATFS
    ../Applications/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
